# Keil uVision project infantry _down.uvprojx, settings and files
target infantry _down (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: infantry _down +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../algorithms_library/attitude_ekf;../algorithms_library/pid;../algorithms_library/rls;../bottom_driven/IMU;../bottom_driven/communication/board;../bottom_driven/communication/chassis_can;../bottom_driven/communication/power;../bottom_driven/motor/motor3508;../bottom_driven/referee;../bottom_driven/telecontrol;../config;../user/chassis;../user/chassis/power;../user/remote
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group MDK-ARM
    ./: startup_stm32h723xx.s
  group Core/Src
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver/Src
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/Common
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
  group Middlewares/Third_Party/FreeRTOS/Source
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group config
    ../config/: peripheral_config.c peripheral_config.h application_config.c application_config.h
  group bottom_driven/IMU
    ../bottom_driven/IMU/: imu.c imu.h
  group bottom_driven/communication/board
    ../bottom_driven/communication/board/: communication.c communication.h
  group bottom_driven/communication/chassis_can
    ../bottom_driven/communication/chassis_can/: chassis_can.c chassis_can.h
  group bottom_driven/communication/power
    ../bottom_driven/communication/power/: power_communication.c power_communication.h
  group bottom_driven/motor/motor3508
    ../bottom_driven/motor/motor3508/: motor3508.c motor3508.h
  group bottom_driven/referee
    ../bottom_driven/referee/: referee.c referee.h referee_wire.h referee_uart.c referee_uart.h
  group bottom_driven/telecontrol
    ../bottom_driven/telecontrol/: telecontrol.c telecontrol.h
  group user/chassis
    ../user/chassis/: chassis.c chassis.h
  group user/chassis/power
    ../user/chassis/power/: chassis_power.c chassis_power.h chassis_power_model.c chassis_power_model.h chassis_power_control.c chassis_power_control.h
  group user/remote
    ../user/remote/: remote_state.c remote_state.h control_input.h
  group algorithms_library/rls
    ../algorithms_library/rls/: rls2.c rls2.h
  group algorithms_library/attitude_ekf
    ../algorithms_library/attitude_ekf/: quaternion_ekf.c quaternion_ekf.h
  group algorithms_library/pid
    ../algorithms_library/pid/: PID.c PID.h
software components: CMSIS:CORE 4.3.0
