# Keil uVision project infantry_up.uvprojx, settings and files
target infantry_up (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry_up +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../algorithms_library/attitude_ekf;../algorithms_library/pid;../bottom_driven/IMU;../bottom_driven/communication/board;../bottom_driven/motor/dial_motor;../bottom_driven/motor/motor2006;../bottom_driven/motor/motor3508;../bottom_driven/motor/motor4310;../config;../user/gimbal;../user/lift;../user/remote;../user/shoot;../user/tasks
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c
  group config
    ../config/: peripheral_config.c peripheral_config.h application_config.c application_config.h
  group bottom_driven/IMU
    ../bottom_driven/IMU/: imu.c imu.h
  group bottom_driven/communication/board
    ../bottom_driven/communication/board/: communication.c communication.h
  group bottom_driven/motor/dial_motor
    ../bottom_driven/motor/dial_motor/: dial_motor.c dial_motor.h
  group bottom_driven/motor/motor2006
    ../bottom_driven/motor/motor2006/: motor2006.c motor2006.h
  group bottom_driven/motor/motor3508
    ../bottom_driven/motor/motor3508/: motor3508.c motor3508.h
  group bottom_driven/motor/motor4310
    ../bottom_driven/motor/motor4310/: motor4310.c motor4310.h
  group user/gimbal
    ../user/gimbal/: cloud_terrace.c cloud_terrace.h
  group user/lift
    ../user/lift/: lift_control.c lift_control.h
  group user/remote
    ../user/remote/: remote_state.c remote_state.h control_input.h
  group user/shoot
    ../user/shoot/: shoot_control.c shoot_control.h shoot_heat.c shoot_heat.h shoot_speed.c shoot_speed.h
  group user/tasks
    ../user/tasks/: upper_tasks.c upper_tasks.h
  group algorithms_library/attitude_ekf
    ../algorithms_library/attitude_ekf/: quaternion_ekf.c quaternion_ekf.h
  group algorithms_library/pid
    ../algorithms_library/pid/: PID.c PID.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
